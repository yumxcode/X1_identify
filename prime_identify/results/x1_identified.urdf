Commit message: Fix URDF writeback (base delta-only); identified URDF 37.4kg all-PC

File: prime_identify/results/x1_identified.urdf (robot description, URDF)
Before this commit: robot x1, 58 links, 57 joints
Links:
- link base_link: mass 23.0769877 -> 6.0811648
